require gcc-for-nvcc8-cross_${PV}.bb
require gcc-for-nvcc-crosssdk.inc
