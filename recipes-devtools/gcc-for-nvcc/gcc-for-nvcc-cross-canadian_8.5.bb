require gcc-${PV}.inc
require gcc-for-nvcc-cross-canadian.inc



