require gcc-${PV}.inc
require gcc-for-nvcc-cross.inc

